# Keil uVision project system.uvprojx, settings and files
target DStep (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: system
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\FreeRTOS\include;.\FreeRTOS-Plus-Trace\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ./: main.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_2.c list.c port.c queue.c readme.txt tasks.c timers.c
    ./FreeRTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_wrappers.h portable.h portmacro.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group GPIO
    ./GPIO/: LED.c LED.h
  group CAN
    ./CAN/: can.c can.h
  group I2C
    ./I2C/: I2C.c I2C.h
  group KEY
    ./KEY/: key.c key.h
  group PWM
    ./PWM/: pwm.c pwm.h
  group ADC
    ./ADC/: adc.c adc.h
  group UART
    ./UART/: uart.c uart.h
  group SPI
    ./SPI/: spi.c spi.h
  group MOTOR
    ./Motor/: GPIOMotor.cpp GPIOMotor.h motor.cpp motor.h MotorBase.h PWMMotor.cpp PWMMotor.h
  group FreeRTOSTrace
    ./FreeRTOS-Plus-Trace/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
    ./FreeRTOS-Plus-Trace/Include/: trcBase.h trcConfig.h trcHardwarePort.h trcKernel.h trcKernelHooks.h trcKernelPort.h trcTypes.h trcUser.h
  group SDIO
    ./SDIO/: sdio_sdcard.c sdio_sdcard.h
  group Temperature
    ./Temperature/: temperature.c temperature.h
software components: CMSIS:CORE 4.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
